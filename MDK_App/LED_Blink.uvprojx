# Keil uVision project LED_Blink.uvprojx, settings and files
target STM32G474RE (6240000::V6.24::ARMCLANG)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08003000,0x0007D000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: LED_Blink
  AfterMake: fromelf.exe --bin --output ..\Flash_program\App.bin .\Objects\LED_Blink.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER,USER_VECT_TAB_ADDRESS ,VECT_TAB_OFFSET = 0x3000
  c include: ..\libraries\CMSIS\Core\Include;..\libraries\CMSIS\Device\ST\STM32G4xx\Include;..\libraries\CMSIS\Device\ST\STM32G4xx\Source\Templates\arm;..\libraries\STM32G4xx_HAL_Driver\Inc;..\BPS\Inc
  memory RVCT4: ROM 0x8003000 size 0x7d000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Objects\LED_Blink.sct
  group StartUP
    ../libraries/CMSIS/Device/ST/STM32G4xx/Include/: stm32g4xx.h stm32g474xx.h system_stm32g4xx.h
    ../libraries/CMSIS/Device/ST/STM32G4xx/Source/Templates/: system_stm32g4xx.c
    ../libraries/CMSIS/Device/ST/STM32G4xx/Source/Templates/arm/: startup_stm32g474xx.s
  group stm32g4xx_ll_driver
    ../libraries/STM32G4xx_HAL_Driver/Inc/: stm32g4xx_ll_bus.h stm32g4xx_ll_gpio.h stm32g4xx_ll_pwr.h stm32g4xx_ll_rcc.h stm32g4xx_ll_system.h stm32g4xx_ll_utils.h
    ../libraries/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_gpio.c stm32g4xx_ll_pwr.c stm32g4xx_ll_rcc.c stm32g4xx_ll_utils.c
  group BPS
    ../BPS/Inc/: Clock_system.h
    ../BPS/src/: Clock_system.c
  group App
    ../App/src/: LED_Blink.c
